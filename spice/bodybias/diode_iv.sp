.title <diode_iv.sp>
