.title <ohmux_test_8i_4b.sp>
.include ../models/nem_ohmux_8i_4b.sp

** Tests one-hot multiplexer using analog inputs **

** Create relay and start at z=0 **
Xmux I0_0 I0_1 I0_2 I0_3 I1_0 I1_1 I1_2 I1_3 I2_0 I2_1 I2_2 I2_3 I3_0 I3_1 I3_2 I3_3 I4_0 I4_1 I4_2 I4_3 I5_0 I5_1 I5_2 I5_3 I6_0 I6_1 I6_2 I6_3 I7_0 I7_1 I7_2 I7_3 S0 S1 S2 S3 S4 S5 S6 S7 Z_0 Z_1 Z_2 Z_3 VDD VB VSS nem_ohmux_8i_4b

** Source voltage **
VI0_0 I0_0 gnd 0.03125V
VI0_1 I0_1 gnd 0.0625V
VI0_2 I0_2 gnd 0.09375V
VI0_3 I0_3 gnd 0.125V
VI1_0 I1_0 gnd 0.15625V
VI1_1 I1_1 gnd 0.1875V
VI1_2 I1_2 gnd 0.21875V
VI1_3 I1_3 gnd 0.25V
VI2_0 I2_0 gnd 0.28125V
VI2_1 I2_1 gnd 0.3125V
VI2_2 I2_2 gnd 0.34375V
VI2_3 I2_3 gnd 0.375V
VI3_0 I3_0 gnd 0.40625V
VI3_1 I3_1 gnd 0.4375V
VI3_2 I3_2 gnd 0.46875V
VI3_3 I3_3 gnd 0.5V
VI4_0 I4_0 gnd 0.53125V
VI4_1 I4_1 gnd 0.5625V
VI4_2 I4_2 gnd 0.59375V
VI4_3 I4_3 gnd 0.625V
VI5_0 I5_0 gnd 0.65625V
VI5_1 I5_1 gnd 0.6875V
VI5_2 I5_2 gnd 0.71875V
VI5_3 I5_3 gnd 0.75V
VI6_0 I6_0 gnd 0.78125V
VI6_1 I6_1 gnd 0.8125V
VI6_2 I6_2 gnd 0.84375V
VI6_3 I6_3 gnd 0.875V
VI7_0 I7_0 gnd 0.90625V
VI7_1 I7_1 gnd 0.9375V
VI7_2 I7_2 gnd 0.96875V
VI7_3 I7_3 gnd 1.0V
VS0 S0 gnd 0V PWL(0s 0V 1ns 1.1V 5000ns 1.1V 5001ns 0V 10000ns 0V 10001ns 0V 15000ns 0V 15001ns 0V 20000ns 0V 20001ns 0V 25000ns 0V 25001ns 0V 30000ns 0V 30001ns 0V 35000ns 0V 35001ns 0V 40000ns 0V)
VS1 S1 gnd 0V PWL(0s 0V 1ns 0V 5000ns 0V 5001ns 1.1V 10000ns 1.1V 10001ns 0V 15000ns 0V 15001ns 0V 20000ns 0V 20001ns 0V 25000ns 0V 25001ns 0V 30000ns 0V 30001ns 0V 35000ns 0V 35001ns 0V 40000ns 0V)
VS2 S2 gnd 0V PWL(0s 0V 1ns 0V 5000ns 0V 5001ns 0V 10000ns 0V 10001ns 1.1V 15000ns 1.1V 15001ns 0V 20000ns 0V 20001ns 0V 25000ns 0V 25001ns 0V 30000ns 0V 30001ns 0V 35000ns 0V 35001ns 0V 40000ns 0V)
VS3 S3 gnd 0V PWL(0s 0V 1ns 0V 5000ns 0V 5001ns 0V 10000ns 0V 10001ns 0V 15000ns 0V 15001ns 1.1V 20000ns 1.1V 20001ns 0V 25000ns 0V 25001ns 0V 30000ns 0V 30001ns 0V 35000ns 0V 35001ns 0V 40000ns 0V)
VS4 S4 gnd 0V PWL(0s 0V 1ns 0V 5000ns 0V 5001ns 0V 10000ns 0V 10001ns 0V 15000ns 0V 15001ns 0V 20000ns 0V 20001ns 1.1V 25000ns 1.1V 25001ns 0V 30000ns 0V 30001ns 0V 35000ns 0V 35001ns 0V 40000ns 0V)
VS5 S5 gnd 0V PWL(0s 0V 1ns 0V 5000ns 0V 5001ns 0V 10000ns 0V 10001ns 0V 15000ns 0V 15001ns 0V 20000ns 0V 20001ns 0V 25000ns 0V 25001ns 1.1V 30000ns 1.1V 30001ns 0V 35000ns 0V 35001ns 0V 40000ns 0V)
VS6 S6 gnd 0V PWL(0s 0V 1ns 0V 5000ns 0V 5001ns 0V 10000ns 0V 10001ns 0V 15000ns 0V 15001ns 0V 20000ns 0V 20001ns 0V 25000ns 0V 25001ns 0V 30000ns 0V 30001ns 1.1V 35000ns 1.1V 35001ns 0V 40000ns 0V)
VS7 S7 gnd 0V PWL(0s 0V 1ns 0V 5000ns 0V 5001ns 0V 10000ns 0V 10001ns 0V 15000ns 0V 15001ns 0V 20000ns 0V 20001ns 0V 25000ns 0V 25001ns 0V 30000ns 0V 30001ns 0V 35000ns 0V 35001ns 1.1V 40000ns 1.1V)
RZ_0 Z_0 gnd 1G
RZ_1 Z_1 gnd 1G
RZ_2 Z_2 gnd 1G
RZ_3 Z_3 gnd 1G
VDD VDD gnd 1.1V
VB VB gnd -2.6V
VSS VS gnd 0V

** Options **
.tran 0.0001us 40000ns
.option post=2
.option runlvl=5 accurate method=gear vntol=1f

.end
